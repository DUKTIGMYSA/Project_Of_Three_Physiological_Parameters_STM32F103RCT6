# Keil uVision project STM32KeilPrj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App\Main;..\App\DataType;..\HW\RCC;..\HW\Timer;..\HW\UART1;..\FW\inc;..\ARM\NVIC;..\ARM\SysTick;..\ARM\System;..\App\LED;..\APP\PackUnpack;..\APP\ProcHostCmd;..\HW\DAC;..\HW\ADC;..\App\SendDataToHost;..\App\KeyOne;..\App\Temp;..\App\ECG;..\App\Bright;..\App\Pluse;..\App\SpoVal;..\App\Filter;..\App\ECG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/PackUnpack/: PackUnpack.c
    ../App/ProcHostCmd/: ProcHostCmd.c
    ../App/SendDataToHost/: SendDataToHost.c
    ../App/KeyOne/: KeyOne.c ProcKeyOne.c
    ../App/Temp/: Temp.c TempRext.c
    ../App/Bright/: Bright.c
    ../App/Pluse/: Pluse.c
    ../App/SpoVal/: SpoVal.c
    ../App/Filter/: Filter.c
    ../App/ECG/: ECG.c
  group HW
    ../HW/RCC/: RCC.c
    ../HW/Timer/: Timer.c
    ../HW/UART1/: Queue.c UART1.c
    ../HW/DAC/: DAC.c Wave.c VDC.c
    ../HW/ADC/: ADC.c U16Queue.c
  group FW
    ../FW/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c
  group ARM
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ../ARM/System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
